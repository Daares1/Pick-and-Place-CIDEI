# Keil uVision project MDNP_P&P_SE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: MDNP_P&P_SE
  c flags: Optim=1
  c include: .\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Config
    ./: Startup.s
    ./Sources/: CM3_MCU.c CM3_PORTS.c CM3_TIMER.c CM3_UART.c Delay.c CM3_QEI.c CM3_PWM.c
  group Program
    ./Sources/: main.c Tiempo.c Fifo.c Accionadores.c Control_valvula.c Encoder.c Comunicacion.c Control_Motor.c
